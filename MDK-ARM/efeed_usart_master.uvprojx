# Keil uVision project efeed_usart_master.uvprojx, settings and files
target efeed_usart_master (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.3.0
  cpu: IRAM(0x20000000-0x20004FFF) IROM(0x8000000-0x800FFFF)  CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: efeed_usart_master +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_FULL_LL_DRIVER,STM32F103xB,HSE_VALUE=8000000,HSE_STARTUP_TIMEOUT=100,LSE_STARTUP_TIMEOUT=5000,LSE_VALUE=32768,HSI_VALUE=8000000,LSI_VALUE=40000,VDD_VALUE=3300,PREFETCH_ENABLE=1
  c include: ../Inc;                               ../Drivers/STM32F1xx_HAL_Driver/Inc;                               ../Drivers/CMSIS/Device/ST/STM32F1xx/Include;                               ../Drivers/CMSIS/Include
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group Application/MDK-ARM
    ./: startup_stm32f103xb.s
  group Application/User
    ../Src/: buttons.c fonts2.c i2c_interface.c nuts_bolts.c screen.c ssd1306.c fsm.c main.c stm32f1xx_it.c
  group Drivers/STM32F1xx_HAL_Driver
    ../Drivers/STM32F1xx_HAL_Driver/Src/: stm32f1xx_ll_gpio.c stm32f1xx_ll_adc.c stm32f1xx_ll_dma.c stm32f1xx_ll_rcc.c stm32f1xx_ll_utils.c stm32f1xx_ll_exti.c stm32f1xx_ll_crc.c stm32f1xx_ll_i2c.c stm32f1xx_ll_spi.c stm32f1xx_ll_pwr.c stm32f1xx_ll_tim.c stm32f1xx_ll_usart.c
  group Drivers/CMSIS
    ../Src/: system_stm32f1xx.c
software components: CMSIS:CORE 4.3.0
